Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2021-04-21T14:38:25
Author: Barth Matthieu
Organization: SITN
Made in: ASIFC - 2.15.0.1000

# IfcProject
LongName: Sans titre

# IfcSite
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcProxy (181)
ProxyType: PRODUCT
